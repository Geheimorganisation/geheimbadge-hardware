File: source/geheimbadge/pixel.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: finalized controller design
Parts:
- renumbered C24 to C1, D24 to D1
